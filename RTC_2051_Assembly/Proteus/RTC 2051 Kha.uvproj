# Keil uVision project RTC 2051 Kha.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: 8051 Kha Keil Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: RTC 2051 code Kha.a
